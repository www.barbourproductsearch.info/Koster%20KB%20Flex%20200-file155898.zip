Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-14T13:35:54
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcBuildingElementProxy: Basic Wall:NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200, Basic Wall:NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200:222023
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200 0.8 mm
Type - IFC - IfcExportAs: IfcCoveingType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_31_76_16: Construction joint sealants; Color: n/a; Finish: n/a; Material: Polyolefin; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Damp and waterproof sealing compound; DurationUnit: year; ExpectedLife: n/a; Features: Does not dry out, but remains permanently plastic and mouldable,Impermeable against water and vapour,Good adhesion to dry and moist mineral substrates, including concrete, masonry, mortar and plaster,It will also bond to ceramics and plastics such as PVC, polyethylene and polypropylene,Gun-applied, one-component product; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster KB-Flex 200; Name: ConstructionJointSealants_KosterKB-Flex200_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/ed949245-1ac4-f864-afe8-6f879d0b2e59/7d93e0ad-4874-479a-9ce5-c5468896a678; Uniclass2015Code: Pr_30_31_76_16; Uniclass2015Title: Construction joint sealants; Uniclass2015Version: Products v1.35; Version: 6
Type - NBS_Data - Colour: Grey; ContainsRedListMaterials: No; Material: Polyolefin; Recyclability: No; RecycledContent: 0; Resistance: 50°C
Classification: Pr_30_31_76_16 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcBuildingElementProxy: Floor:NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200, Floor:NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200:221883
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200 0.8 mm
Type - IFC - IfcExportAs: IfcCoveingType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_31_76_16: Construction joint sealants; Color: n/a; Finish: n/a; Material: Polyolefin; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Damp and waterproof sealing compound; DurationUnit: year; ExpectedLife: n/a; Features: Does not dry out, but remains permanently plastic and mouldable,Impermeable against water and vapour,Good adhesion to dry and moist mineral substrates, including concrete, masonry, mortar and plaster,It will also bond to ceramics and plastics such as PVC, polyethylene and polypropylene,Gun-applied, one-component product; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster KB-Flex 200; Name: ConstructionJointSealants_KosterKB-Flex200_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_ConstructionJointSealants_KosterKB-Flex200; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/ed949245-1ac4-f864-afe8-6f879d0b2e59/b050bc0d-ca46-4744-8883-3841f6db7a80; Uniclass2015Code: Pr_30_31_76_16; Uniclass2015Title: Construction joint sealants; Uniclass2015Version: Products v1.35; Version: 5
Type - NBS_Data - Colour: Grey; ContainsRedListMaterials: No; Material: Polyolefin; Recyclability: No; RecycledContent: 0; Resistance: 50°C
Classification: Pr_30_31_76_16 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
